Commit message: force sensor fix

File: urdf/gen3_ESAOTE_FTSense.urdf (robot description, URDF)
Before this commit: robot gen3, 11 links, 10 joints
Links:
- link end_effector_link: mass 0.632 -> 0.577
